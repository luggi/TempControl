# Keil uVision project TempControl.uvproj, settings and files
target TempControl (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: TempControl +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c misc: --c99
  c include: .\lib\STM32F4xx_StdPeriph_Driver\inc;.\lib\CMSIS\ST\STM32F4xx\Include;.\lib\CMSIS\Include;.\lib\STM32F4xx_StdPeriph_Driver\src;.\;.\lib\usb_cdc_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: board.h drv_system.c main.c stm32f4xx_it.c pid.c stm32_ub_dac.c cli.c gpio.c output.c init.c drv_max31855.c autoTuning.c config.c drv_adcdma.c serial.c
  group System
    ./lib/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dac.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_crc.c misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_dma.c
    ./src/: system_stm32f4xx.c
  group startup
    ./lib/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group usb-cdc
    ./lib/usb_cdc_lib/: stm32_ub_usb_cdc.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
